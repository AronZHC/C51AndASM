# Keil uVision project main_c.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: main_c
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 ASM2C.c a_cfunc.a51
    G:/Keil_v5/C51/LIB/: C51S.LIB
